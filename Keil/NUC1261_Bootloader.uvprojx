# Keil uVision project NUC1261_Bootloader.uvprojx, settings and files
target Target_Base_0000 (6230000::V6.23::ARMCLANG)
  device: NUC1261NE4AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Target_Base_0000
  AfterMake: fromelf --bin ".\objects\@L.axf" --output ".\objects\@L.bin"
  AfterMake: fromelf --text -c ".\objects\@L.axf" --output ".\objects\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\app;..\service;..\driver;..\bsp;..\common;..\..\..\NUC1261BSP-master\Library\CMSIS\Include;..\..\..\NUC1261BSP-master\Library\Device\Nuvoton\NUC1261\Include;..\..\..\NUC1261BSP-master\Library\StdDriver\inc;..\hal
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC1261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../NUC1261BSP-master/Library/Device/Nuvoton/NUC1261/Source/: system_NUC1261.c
    ../../../NUC1261BSP-master/Library/Device/Nuvoton/NUC1261/Source/ARM/: startup_NUC1261.s
  group app
    ../app/: main.c BootloaderProcess.h BootloaderProcess.c
  group service
    ../service/: flash_service.h flash_service.c Select_fw.h Select_fw.c ota_scheduler.h ota_offset_patcher.c ota_offset_patcher.h ota_patch_meta.c ota_patch_meta.h
  group common
    ../common/: fw_info.h
  group Library
    ../../../NUC1261BSP-master/Library/StdDriver/src/: clk.c fmc.c gpio.c retarget.c sys.c uart.c wdt.c
  group hal
    ../hal/: hal_sys.c hal_sys.h hal_gpio.c hal_gpio.h hal_uart.c hal_uart.h hal_flash.c hal_flash.h
  group driver
    ../driver/: drv_sys.c drv_sys.h uart_drv.c uart_drv.h
  group bsp
    ../bsp/: bsp_config.h bsp_flash.h bsp_flash.c MeterV52PinConfig.h MeterV52PinConfig.c bsp_init.c bsp_init.h bsp_uart.c bsp_uart.h bsp_gpio.c bsp_gpio.h
